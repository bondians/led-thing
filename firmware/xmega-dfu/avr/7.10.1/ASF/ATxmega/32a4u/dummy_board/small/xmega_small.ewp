# IAR project xmega_small.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-xmega-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32a4u ATxmega32A4U
  ICCAVR.CCDefines: BOARD=DUMMY_BOARD
  ICCAVR.IExtraOptions: --no_path_in_file_macros
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; xmega/drivers/usb; ../../common/xmega/drivers/usb; common/services/clock; ../../common/common/services/clock; common/services/usb/class/dfu_flip/device/bootloader/xmega/conf; ../../common/common/services/usb/class/dfu_flip/device/bootloader/xmega/conf; xmega/drivers/nvm; ../../common/xmega/drivers/nvm; common/services/usb/class/dfu_flip/device/bootloader/xmega; ../../common/common/services/usb/class/dfu_flip/device/bootloader/xmega; xmega/utils/preprocessor; ../../common/xmega/utils/preprocessor; common/boards; ../../common/common/boards; xmega/utils; ../../common/xmega/utils; common/services/usb/udc; ../../common/common/services/usb/udc; common/services/usb; ../../common/common/services/usb; xmega/boards/dummy; ../../common/xmega/boards/dummy; common/services/usb/class/dfu_flip/device; ../../common/common/services/usb/class/dfu_flip/device; common/services/isp/flip; ../../common/common/services/isp/flip; xmega/boards; ../../common/xmega/boards; common/utils; ../../common/common/utils; common/services/usb/class/dfu_flip/device/bootloader/xmega/atxmega32a4u/iar; ../../common/common/services/usb/class/dfu_flip/device/bootloader/xmega/atxmega32a4u/iar; xmega/drivers/cpu; ../../common/xmega/drivers/cpu; common/services/usb/class/dfu_flip; ../../common/common/services/usb/class/dfu_flip; common/services/usb/class/dfu_flip/device/bootloader/xmega/atxmega32a4u/iar; ../../common/common/services/usb/class/dfu_flip/device/bootloader/xmega/atxmega32a4u/iar
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=DUMMY_BOARD
  XLINK.XclFile: common/services/usb/class/dfu_flip/device/bootloader/xmega/atxmega32a4u/iar/atxmega32a4u_boot.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD
  group common/boards
    ../../common/common/boards/: board.h
  group common/services/clock
    common/services/clock/: genclk.h
    ../../common/common/services/clock/: osc.h pll.h sysclk.h
  group common/services/clock/xmega
    ../../common/common/services/clock/xmega/: osc.h pll.h sysclk.c sysclk.h
  group common/services/isp/flip
    common/services/isp/flip/: flip_protocol.h isp.h
  group common/services/isp/flip/xmega
    common/services/isp/flip/xmega/: cstartup.s90 isp.c
  group common/services/usb
    ../../common/common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/dfu_flip
    common/services/usb/class/dfu_flip/: usb_protocol_dfu.h
  group common/services/usb/class/dfu_flip/device
    common/services/usb/class/dfu_flip/device/: udi_dfu_atmel.c udi_dfu_atmel.h udi_dfu_atmel_conf.h udi_dfu_atmel_desc.c
  group common/services/usb/class/dfu_flip/device/bootloader/xmega
    common/services/usb/class/dfu_flip/device/bootloader/xmega/: main.c main.h sysclk_opt.c
  group common/services/usb/class/dfu_flip/device/bootloader/xmega/atxmega32a4u/iar
    common/services/usb/class/dfu_flip/device/bootloader/xmega/atxmega32a4u/iar/: asf.h
  group common/services/usb/class/dfu_flip/device/bootloader/xmega/conf
    common/services/usb/class/dfu_flip/device/bootloader/xmega/conf/: conf_board.h conf_clock.h conf_isp.h conf_usb.h
  group common/services/usb/udc
    ../../common/common/services/usb/udc/: udc.h udc_desc.h udd.h udi.h
    common/services/usb/udc/: udc_dfu_small.c
  group common/utils
    ../../common/common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../common/common/utils/interrupt/: interrupt_avr8.h
  group xmega/boards/dummy
    ../../common/xmega/boards/dummy/: dummy_board.h
  group xmega/drivers/cpu
    ../../common/xmega/drivers/cpu/: ccp.h ccp.s xmega_reset_cause.h
  group xmega/drivers/nvm
    ../../common/xmega/drivers/nvm/: nvm.c nvm.h nvm_asm.s
  group xmega/drivers/usb
    ../../common/xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/utils
    ../../common/xmega/utils/: assembler.h compiler.h progmem.h status_codes.h
  group xmega/utils/assembler
    ../../common/xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../common/xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../common/xmega/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
